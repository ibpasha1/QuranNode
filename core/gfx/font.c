#include "font.h"
#include <string.h>

// Minimal 5x7 font bitmap (printable ASCII 32-126)
// Each character is 5 bytes (5 columns x 7 rows, packed vertically)
static const uint8_t font_5x7_data[] = {
    // Space (32)
    0x00, 0x00, 0x00, 0x00, 0x00,
    // ! (33)
    0x00, 0x00, 0x5F, 0x00, 0x00,
    // " (34)
    0x00, 0x07, 0x00, 0x07, 0x00,
    // # (35)
    0x14, 0x7F, 0x14, 0x7F, 0x14,
    // $ (36)
    0x24, 0x2A, 0x7F, 0x2A, 0x12,
    // % (37)
    0x23, 0x13, 0x08, 0x64, 0x62,
    // & (38)
    0x36, 0x49, 0x55, 0x22, 0x50,
    // ' (39)
    0x00, 0x05, 0x03, 0x00, 0x00,
    // ( (40)
    0x00, 0x1C, 0x22, 0x41, 0x00,
    // ) (41)
    0x00, 0x41, 0x22, 0x1C, 0x00,
    // * (42)
    0x08, 0x2A, 0x1C, 0x2A, 0x08,
    // + (43)
    0x08, 0x08, 0x3E, 0x08, 0x08,
    // , (44)
    0x00, 0x50, 0x30, 0x00, 0x00,
    // - (45)
    0x08, 0x08, 0x08, 0x08, 0x08,
    // . (46)
    0x00, 0x60, 0x60, 0x00, 0x00,
    // / (47)
    0x20, 0x10, 0x08, 0x04, 0x02,
    // 0-9 (48-57)
    0x3E, 0x51, 0x49, 0x45, 0x3E,
    0x00, 0x42, 0x7F, 0x40, 0x00,
    0x42, 0x61, 0x51, 0x49, 0x46,
    0x21, 0x41, 0x45, 0x4B, 0x31,
    0x18, 0x14, 0x12, 0x7F, 0x10,
    0x27, 0x45, 0x45, 0x45, 0x39,
    0x3C, 0x4A, 0x49, 0x49, 0x30,
    0x01, 0x71, 0x09, 0x05, 0x03,
    0x36, 0x49, 0x49, 0x49, 0x36,
    0x06, 0x49, 0x49, 0x29, 0x1E,
    // : (58)
    0x00, 0x36, 0x36, 0x00, 0x00,
    // ; (59)
    0x00, 0x56, 0x36, 0x00, 0x00,
    // < (60)
    0x00, 0x08, 0x14, 0x22, 0x41,
    // = (61)
    0x14, 0x14, 0x14, 0x14, 0x14,
    // > (62)
    0x41, 0x22, 0x14, 0x08, 0x00,
    // ? (63)
    0x02, 0x01, 0x51, 0x09, 0x06,
    // @ (64)
    0x32, 0x49, 0x79, 0x41, 0x3E,
    // A-Z (65-90)
    0x7E, 0x11, 0x11, 0x11, 0x7E,
    0x7F, 0x49, 0x49, 0x49, 0x36,
    0x3E, 0x41, 0x41, 0x41, 0x22,
    0x7F, 0x41, 0x41, 0x22, 0x1C,
    0x7F, 0x49, 0x49, 0x49, 0x41,
    0x7F, 0x09, 0x09, 0x01, 0x01,
    0x3E, 0x41, 0x41, 0x51, 0x32,
    0x7F, 0x08, 0x08, 0x08, 0x7F,
    0x00, 0x41, 0x7F, 0x41, 0x00,
    0x20, 0x40, 0x41, 0x3F, 0x01,
    0x7F, 0x08, 0x14, 0x22, 0x41,
    0x7F, 0x40, 0x40, 0x40, 0x40,
    0x7F, 0x02, 0x04, 0x02, 0x7F,
    0x7F, 0x04, 0x08, 0x10, 0x7F,
    0x3E, 0x41, 0x41, 0x41, 0x3E,
    0x7F, 0x09, 0x09, 0x09, 0x06,
    0x3E, 0x41, 0x51, 0x21, 0x5E,
    0x7F, 0x09, 0x19, 0x29, 0x46,
    0x46, 0x49, 0x49, 0x49, 0x31,
    0x01, 0x01, 0x7F, 0x01, 0x01,
    0x3F, 0x40, 0x40, 0x40, 0x3F,
    0x1F, 0x20, 0x40, 0x20, 0x1F,
    0x7F, 0x20, 0x18, 0x20, 0x7F,
    0x63, 0x14, 0x08, 0x14, 0x63,
    0x03, 0x04, 0x78, 0x04, 0x03,
    0x61, 0x51, 0x49, 0x45, 0x43,
    // [ (91)
    0x00, 0x00, 0x7F, 0x41, 0x41,
    // \ (92)
    0x02, 0x04, 0x08, 0x10, 0x20,
    // ] (93)
    0x41, 0x41, 0x7F, 0x00, 0x00,
    // ^ (94)
    0x04, 0x02, 0x01, 0x02, 0x04,
    // _ (95)
    0x40, 0x40, 0x40, 0x40, 0x40,
    // ` (96)
    0x00, 0x01, 0x02, 0x04, 0x00,
    // a-z (97-122)
    0x20, 0x54, 0x54, 0x54, 0x78,
    0x7F, 0x48, 0x44, 0x44, 0x38,
    0x38, 0x44, 0x44, 0x44, 0x20,
    0x38, 0x44, 0x44, 0x48, 0x7F,
    0x38, 0x54, 0x54, 0x54, 0x18,
    0x08, 0x7E, 0x09, 0x01, 0x02,
    0x08, 0x54, 0x54, 0x54, 0x3C,
    0x7F, 0x08, 0x04, 0x04, 0x78,
    0x00, 0x44, 0x7D, 0x40, 0x00,
    0x20, 0x40, 0x44, 0x3D, 0x00,
    0x00, 0x7F, 0x10, 0x28, 0x44,
    0x00, 0x41, 0x7F, 0x40, 0x00,
    0x7C, 0x04, 0x18, 0x04, 0x78,
    0x7C, 0x08, 0x04, 0x04, 0x78,
    0x38, 0x44, 0x44, 0x44, 0x38,
    0x7C, 0x14, 0x14, 0x14, 0x08,
    0x08, 0x14, 0x14, 0x18, 0x7C,
    0x7C, 0x08, 0x04, 0x04, 0x08,
    0x48, 0x54, 0x54, 0x54, 0x20,
    0x04, 0x3F, 0x44, 0x40, 0x20,
    0x3C, 0x40, 0x40, 0x20, 0x7C,
    0x1C, 0x20, 0x40, 0x20, 0x1C,
    0x3C, 0x40, 0x30, 0x40, 0x3C,
    0x44, 0x28, 0x10, 0x28, 0x44,
    0x0C, 0x50, 0x50, 0x50, 0x3C,
    0x44, 0x64, 0x54, 0x4C, 0x44,
    // { (123)
    0x00, 0x08, 0x36, 0x41, 0x00,
    // | (124)
    0x00, 0x00, 0x7F, 0x00, 0x00,
    // } (125)
    0x00, 0x41, 0x36, 0x08, 0x00,
    // ~ (126)
    0x08, 0x04, 0x08, 0x10, 0x08,
};

const Font font_tiny = {
    .data = font_5x7_data,
    .char_width = 5,
    .char_height = 7,
    .first_char = 32,
    .last_char = 126,
    .spacing = 1,
    .scale = 1,
};

const Font font_small = {
    .data = font_5x7_data,
    .char_width = 5,
    .char_height = 7,
    .first_char = 32,
    .last_char = 126,
    .spacing = 1,
    .scale = 2,
};

const Font font_medium = {
    .data = font_5x7_data,
    .char_width = 5,
    .char_height = 7,
    .first_char = 32,
    .last_char = 126,
    .spacing = 1,
    .scale = 3,
};

const Font font_large = {
    .data = font_5x7_data,
    .char_width = 5,
    .char_height = 7,
    .first_char = 32,
    .last_char = 126,
    .spacing = 2,
    .scale = 4,
};

void font_draw_char(Canvas *c, int x, int y, const Font *f, char ch, color_t color)
{
    if (ch < f->first_char || ch > f->last_char) return;

    int idx = (ch - f->first_char) * f->char_width;
    uint8_t s = f->scale;

    for (int col = 0; col < f->char_width; col++) {
        uint8_t column = f->data[idx + col];
        for (int row = 0; row < f->char_height; row++) {
            if (column & (1 << row)) {
                // Render as scale x scale block
                for (int sy = 0; sy < s; sy++) {
                    for (int sx = 0; sx < s; sx++) {
                        canvas_pixel(c, x + col * s + sx, y + row * s + sy, color);
                    }
                }
            }
        }
    }
}

void font_draw_string(Canvas *c, int x, int y, const Font *f, const char *str, color_t color)
{
    int cursor_x = x;
    uint8_t s = f->scale;
    int char_advance = f->char_width * s + f->spacing * s;
    while (*str) {
        // Stop drawing if the next character would start beyond the canvas
        if (cursor_x + f->char_width * s > c->width) break;
        // Skip characters that are entirely off the left edge
        if (cursor_x + f->char_width * s > 0) {
            font_draw_char(c, cursor_x, y, f, *str, color);
        }
        cursor_x += char_advance;
        str++;
    }
}

int font_string_width(const Font *f, const char *str)
{
    int len = strlen(str);
    if (len == 0) return 0;
    uint8_t s = f->scale;
    return len * f->char_width * s + (len - 1) * f->spacing * s;
}

void font_draw_string_centered(Canvas *c, int y, const Font *f, const char *str, color_t color)
{
    int w = font_string_width(f, str);
    int x = (c->width - w) / 2;
    font_draw_string(c, x, y, f, str, color);
}

void font_draw_string_right(Canvas *c, int x, int y, const Font *f, const char *str, color_t color)
{
    int w = font_string_width(f, str);
    font_draw_string(c, x - w, y, f, str, color);
}

int font_max_chars(const Font *f, int avail_px)
{
    if (avail_px <= 0) return 0;
    int cw = f->char_width * f->scale;
    int sp = f->spacing * f->scale;
    // font_string_width(n) = n*cw + (n-1)*sp = n*(cw+sp) - sp
    // Solve: n*(cw+sp) - sp <= avail_px  →  n <= (avail_px + sp) / (cw + sp)
    int n = (avail_px + sp) / (cw + sp);
    return n > 0 ? n : 0;
}

void font_truncate(char *dst, int dst_size, const char *src, const Font *f, int avail_px)
{
    if (dst_size <= 0) return;
    int max_c = font_max_chars(f, avail_px);
    if (max_c >= dst_size) max_c = dst_size - 1;

    int len = (int)strlen(src);
    if (len <= max_c) {
        // Fits — copy as-is
        strncpy(dst, src, dst_size - 1);
        dst[dst_size - 1] = '\0';
    } else {
        // Truncate with "..." prefix showing the tail
        if (max_c < 4) {
            // Too tight for ellipsis — just show what fits from the end
            strncpy(dst, src + len - max_c, max_c);
            dst[max_c] = '\0';
        } else {
            int tail = max_c - 3;
            dst[0] = '.'; dst[1] = '.'; dst[2] = '.';
            strncpy(dst + 3, src + len - tail, tail);
            dst[3 + tail] = '\0';
        }
    }
}
